# IAR project MP3Player.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xE ST STM32F401xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; DEBUG
  ICCARM.CCIncludePath2: Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; PJDF; MP3data; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; Adafruit\Adafruit-GFX; Adafruit\Adafruit_FT6206; Adafruit\Adafruit_ILI9341; Arduino\SD\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: MP3Player.sim
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: BSP\layout.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F401xx; NDEBUG
  ICCARM.CCIncludePath2: Util; BSP; BSP\CMSIS; BSP\ST\StdPeripheralDrivers; PJDF; MP3data; App\uCOS; Micrium\Software\uCOS-II\Source; Micrium\Software\uCOS-II\ARM-Cortex-M4\IAR; Adafruit\Adafruit-GFX; Adafruit\Adafruit_FT6206; Adafruit\Adafruit_ILI9341
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: MP3Player.srec
  group Adafruit/Adafruit-GFX
    Adafruit/Adafruit-GFX/: Adafruit_GFX.cpp Adafruit_GFX.h glcdfont.c library.properties license.txt README.txt
  group Adafruit/Adafruit_ILI9341
    Adafruit/Adafruit_ILI9341/: Adafruit_ILI9341.cpp Adafruit_ILI9341.h library.properties README.txt
  group App
    App/: dfs_main.c DFS_pub.h main.c mp3_main.c mp3_prv.h MP3_pub.h mp3_stream.c mp3_strm_util.c tasks.c tch_ctrl_prv_util.h tch_ctrl_util.c
  group App/uCOS
    App/uCOS/: app_cfg.h app_hooks.c os_cfg.h TSK_pub.h
  group Arduino/BSP
    BSP/: bsp.c bsp.h bspI2c.c bspI2c.h bspLcd.c bspLcd.h bspMp3.c bspMp3.h bspSD.c bspSD.h bspSpi.c bspSpi.h bspUart.c bspUart.h datainit.c debugger.c hw_init.c hw_init.h layout.icf nucleoboard.h startup.s
  group Arduino/BSP/CMSIS
    BSP/CMSIS/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h stm32f4xx.h system_stm32f2xx.c system_stm32f4xx.h
  group Arduino/BSP/ST/StdPeripheralDrivers
    BSP/ST/StdPeripheralDrivers/: misc.c misc.h stm32f4xx_conf.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_usart.c stm32f4xx_usart.h
  group Arduino/SD/src
    Arduino/SD/src/: File.cpp README.txt SD.cpp SD.h
  group Arduino/SD/src/utility
    Arduino/SD/src/utility/: FatStructs.h Sd2Card.cpp Sd2Card.h SdFat.h SdFatmainpage.h SdFatUtil.h SdFile.cpp SdInfo.h SdVolume.cpp
  group Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR
    Micrium/Software/uCOS-II/ARM-Cortex-M4/IAR/: os_cpu.h os_cpu_a - Implemented.asm os_cpu_a - NotImplemented.asm os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Micrium/Software/uCOS-II/Source
    Micrium/Software/uCOS-II/Source/: os_cfg_r.h os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.c ucos_ii.h
  group PJDF
    PJDF/: pjdf.c pjdf.h pjdfCtrlLcdILI9341.h pjdfCtrlMp3VS1053.h pjdfCtrlSDAdafruit.h pjdfCtrlSpi.h pjdfCtrlTchCtrlFT6206.h pjdfInternal.h pjdfInternalLcdILI9341.c pjdfInternalMp3VS1053.c pjdfInternalSDAdafruit.c pjdfInternalSPI.c pjdfInternalTchCtrlFT6206.c
  group Util
    Util/: print.c print.h
